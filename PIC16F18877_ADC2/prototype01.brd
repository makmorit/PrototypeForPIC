# Repository makmorit/PrototypeForPIC

## EAGLE design PIC16F18877_ADC2/prototype01.brd

Parts:
C1, C2: 1uF; CAP_100MIL
C3: 10uF; ELECAP_D5_100MIL
C4, C5, C7, C8: 0.1uF; CAP_100MIL
C6: 10uF; CAP_100MIL
CN1: 12V_IN; HEADER_2PIN_POWER_IF
CN2: PIC_PORTA_IF; PIC_PORTA_IF_9PIN
CN3: UART_IF; UART_IF_3PIN
CN4: PIC_CN_H; HEADER_6PIN
CN5: AE-MICRO-SD-DIP
CN6: I2C_IF; I2C_IF_4PIN
CN7: PIC_PORTB_IF; PIC_PORTB_IF_5PIN
CN8: PIC_PORTE_IF; PIC_PORTE_IF_4PIN
CN9: PIC_PORTC_IF; PIC_PORTC_IF_4PIN
CN10: PIC_PORTD_IF; PIC_PORTD_IF_9PIN
D1: LED_5MM; LED5MM
G1: CH25-2032LF
H1, H2, H3, H4: MOUNT_HOLE_3.2; 3,2
L1: 47uH; INDUCTOR_0207_300MIL
R1, R7, R8, R9: 10k; RESISTOR_0204_200MIL
R2: 330; RESISTOR_0204_200MIL
R3, R6: 100k; RESISTOR_0204_200MIL
R4, R5: 47k; RESISTOR_0204_200MIL
SW1: 10-XX; B3F-10XX
U1: XC6202P332TH; TO92-LINE
U2: PIC16F18877-I/P; DIL40
U3: AE-AQM1602A
U4: AE-RTC-8564NB; DIL8_AE-RTC-8564NB

Connections:
0V: C1.2, C2.2, C3.-, C4.2, C5.2, C6.2, C7.2, C8.2, CN1.1 (GND), CN2.1 (GND), CN3.1 (GND), CN4.3 (VSS), CN5.6 (VSS), CN6.1 (GND), CN7.1 (GND), CN8.1 (GND), CN9.1 (GND), CN10.1 (GND), G1.-, R2.1, R9.1, SW1.1, SW1.3 (P1), U1.2 (VSS), U2.12 (VSS), U2.31 (VSS1), U3.1 (GND), U4.4 (VSS)
+3V: C8.1, G1.+, U4.8 (VDD)
+3V3: C1.1, C4.1, C5.1, CN4.2 (VDD), CN6.4 (VDD), L1.2, R1.2, R7.2, R8.2, U1.1 (VOUT), U2.11 (VDD), U2.32 (VDD1), U3.4 (V+)
+12V: C2.1, C3.+, CN1.2 (VDD), U1.3 (VIN)
unnamed: D1.K (C), R2.2
unnamed: CN4.4 (PGD), CN7.5 (RB7), U2.40 (RB7/ICSPDAT)
unnamed: CN4.1 (VPP/!MCLR), R1.1, SW1.2 (S), SW1.4 (S1), U2.1 (VPP/!MCLR!/RE3)
unnamed: CN4.5 (PGC), CN7.4 (RB6), U2.39 (RB6/ICSPCLK)
unnamed: D1.A, U2.24 (RC5)
unnamed: CN5.5 (CLK), R3.1, U2.34 (RB1)
unnamed: CN5.2 (CD/DAT3), R6.1, U2.33 (RB0)
unnamed: CN5.7 (DAT0), R4.1, U2.35 (RB2)
unnamed: C6.1, C7.1, CN5.4 (VDD), L1.1, R3.2, R4.2, R5.2, R6.2
unnamed: CN2.2 (RA0), U2.2 (RA0/ANA0)
unnamed: CN2.3 (RA1), U2.3 (RA1)
unnamed: CN5.3 (CMD), R5.1, U2.36 (RB3)
unnamed: CN2.4 (RA2), U2.4 (RA2)
unnamed: CN2.5 (RA3), U2.5 (RA3)
unnamed: CN2.6 (RA4), U2.6 (RA4)
unnamed: R9.2, U4.1 (CLKOE)
unnamed: CN2.7 (RA5), U2.7 (RA5)
unnamed: CN7.2 (RB4), U2.37 (RB4)
unnamed: CN7.3 (RB5), U2.38 (RB5)
RA6: CN2.8 (RA6), U2.14 (RA6/OSC2)
RA7: CN2.9 (RA7), U2.13 (RA7/OSC1)
RC0: CN9.2 (RC0), U2.15 (RC0)
RC1: CN9.3 (RC1), U2.16 (RC1)
RC2: CN9.4 (RC2), U2.17 (RC2)
RD0: CN10.2 (RD0), U2.19 (RD0)
RD1: CN10.3 (RD1), U2.20 (RD1)
RD2: CN10.4 (RD2), U2.21 (RD2)
RD3: CN10.5 (RD3), U2.22 (RD3)
RD4: CN10.6 (RD4), U2.27 (RD4)
RD5: CN10.7 (RD5), U2.28 (RD5)
RD6: CN10.8 (RD6), U2.29 (RD6)
RD7: CN10.9 (RD7), U2.30 (RD7)
RE0: CN8.2 (RE0), U2.8 (RE0)
RE1: CN8.3 (RE1), U2.9 (RE1)
RE2: CN8.4 (RE2), U2.10 (RE2)
SCL1: CN6.3 (SCL), R7.1, U2.18 (RC3/SCL1), U3.3 (SCL), U4.6 (SCL)
SDA1: CN6.2 (SDA), R8.1, U2.23 (RC4/SDA1), U3.2 (SDA), U4.5 (SDA)
UART_RX: CN3.2 (RX), U2.26 (RC7)
UART_TX: CN3.3 (TX), U2.25 (RC6)

Notes on the sheet:
【UART接続用コネクター】 USB-UART変換基板などを、 こちらのコネクターに接続できます。
PIC16F18877 microSDサンプル 小型LCD／RTCCを接続
Ｉ２Ｃ接続小型キャラクタ ＬＣＤモジュール ピッチ変換キット [AE-AQM1602A(KIT)] を使用します。
リアルタイムクロック モジュール [RTC-8564NB] を使用します。
【タクトスイッチ】
【CR2032(ボタン乾電池)】 リアルタイムクロック モジュールには、常時 3Vを給電してください。 CR2032から非給電時に マイコンを起動しても、 リアルタイムクロックは 動作しませんので ご注意ください。
マイクロＳＤ カードスロット ＤＩＰ化キット [AE-MICRO-SD-DIP] を使用します。
【LED】 カウントダウン中は LEDが点灯します。 カウントダウンが停止すると LEDが消灯します。
SW1： ボタン押下で 180秒間の カウントダウンが 開始されます。
【外部I2Cデバイス接続用コネクター】 温度センサーなどの外部I2Cデバイスを こちらのコネクターに接続できます。

Board: 2 copper layers, 95.0 x 72.0 mm, 39 parts (0 on the bottom side), 43 nets.

## Commit log

2017-04-08 回路図初版
    PIC16F18877の実験用回路図を追加
2017-04-08 回路図PDF初版
    PIC16F18877の実験用回路図
2017-04-08 回路図を修正
    LCDモジュール(AE-AQM1602A)を回路に追加
2017-04-14 [WIP] PIC16F18877サンプルコードの初版
2017-04-14 [WIP] PIC16F18877サンプルコード小修正
    タブ文字を４個の半角スペースに変更
2017-04-15 コードを再編成
    実際の動作確認結果を反映
2017-04-15 [WIP] I2Cロジックを入れた初版
    ただしI2Cの動作が失敗してしまうので、コメントアウトしています。
    （start_conditionでbusy状態と判定されフリーズ）
    なので実際に動作するのはLチカ部分だけです。
    時間があればリトライしてみます。
2017-04-15 [WIP] 不要ロジックおよびコメントを削除
2017-04-15 PIC16F1823サンプルコードの初版
    I2C LCDを接続したサンプルを作成
    ボタンを押すとカウントダウン開始（180秒間）
    残秒数カウンターをLCDに表示します。
2017-04-16 PIC16F1823サンプルコードの回路図初版
2017-04-16 I2C LCD開通
    (1) 以下のデモ機能も追加
    ・タクトスイッチ押下で、ヘルスチェックタイマーをカウントダウン
    ・残カウンターをディスプレイ表示
    (2) ソースコードおよびコメントを大幅に見直し
2017-04-16 I2C LCD開通時の回路図
2017-04-17 ADC2評価コード追加
    Basic mode で動作確認
2017-04-23 ソースコードを再編成＋動作電圧3.3V化
    ！！！注意！！！動作電圧3.3Vに変更しています。
    以下の機能が動作するところまで確認
    ・ヘルスチェックLED点滅（１秒ごと）
    ・I2C LCD表示
    ・ラーメンタイマー機能（ボタン押下で180秒カウントダウン開始）
2017-04-23 回路図を3.3Vに修正
2017-04-23 [WIP] STTS751関連処理の追加
    I2Cのスタートコンディション処理がおかしいことが判明
    （ACKチェックのロジック）
    後日、処理を見直します。
2017-04-24 STTS751関連処理の追加／修正
    ・I2C処理ロジックを全般的に見直し
    ・温度計測値の小数点以下が取得できるよう修正
    ・度を表すカスタム文字が表示できるよう修正
2017-04-24 回路図を修正
    I2Cセンサーを追加
2017-04-24 ignoreリストを修正
    本来必要なファイルが登録されていないことが判明したため
2017-04-24 足りないファイルを追加登録
2017-04-24 ignoreの見直し
    登録不要な拡張子を追加(RMWiFiController、NixieTubeに合わせる）
2017-04-24 不要ファイルを削除
2017-04-30 PIC16F18857サンプルコードの初版
    UART, I2C LCDを接続したサンプルを作成
    ボタンを押すとカウントダウン開始（180秒間）
    残秒数カウンターをLCDに表示します。
    温度を１秒ごとにUART出力します。
2017-04-30 PIC16F18857サンプルコードの回路図初版
2017-05-06 SPIバスにM25PX16を取付け、疎通を確認
    Manufacturer ID の読み出しまで確認しています。
2017-05-07 フラッシュメモリー入出力処理を追加
    ・１秒ごとにフラッシュメモリーに温度情報を保存
    ・ボタン押下でメモリーに保存されている情報をLCDにプリント
    ・セクター消去処理を追加
2017-05-08 フラッシュメモリー入出力処理を修正
    ・不要な処理、関数を削除
    ・readの前にwait_in_progressを入れるよう修正
    ・関数名、変数名の見直し
    ・UART出力時のwaitを削除
2017-05-09 フラッシュメモリー等を回路図に追加
2017-05-09 リネーム
2017-05-09 'eval_M25PX16' の元ファイルを復元
2017-05-13 microSDカードでread/write/appendを確認時のコード
2017-05-14 ソースコードを再編成
2017-05-14 ignoreの更新
    他のブランチから、開発中のプロジェクト情報が抹消されないよう対策
2017-05-14 microSDカードデバイス増設対応
    microSDカードテスト処理を組み込んで動作確認
    その他のI2CLCD／センサー／スイッチ／カウントダウン機能も正常稼働を確認ずみ
2017-05-14 確認用回路図
2017-05-19 配線を修正
2017-05-19 ソースコードを再編成
    ・共通ソースを入れ替え
    ・カウントダウン中だけヘルスチェックLEDが点灯するよう修正
    ・ADC2まわりについては修正なし
2017-05-19 ADC2計測方法をバースト平均モードに変更
2017-05-19 平均化モードのサンプル収集数を１６に設定
2017-05-26 microSDカード接続のための回路図／コードを追加
    sdcard、sdcard_testは、動作確認用の一時的なファイルなので後日必ず削除してください。
2017-05-28 RTCC接続テスト用のコードを追加
    ・RTCC初期化／現在時刻取得関数を実装
    ・RTCCアジャスト関数は未実装
2017-05-28 不要なライブラリーを削除
2017-05-28 RTCCを接続した回路図を作成
2017-05-29 RTCCに常時給電させるように回路を修正
    同時に部品番号／コメントを見直し
2017-05-30 時刻アジャスト機能を追加
    ・UARTに接続後、コンソールから A [Enter] を入力するとプロンプトを表示
    ・プロンプトに続いて 2017-05-30 20:00:00 形式で入力された時刻をRTCCに設定
2017-05-30 回路から使用しないスイッチを削除
2017-05-31 処理の見直し
    不要な処理を削除
    変数名が不適切なものは変更
    RTCCが使用可能かどうかを、モジュール全体で共有できるようにする
    RTCCが使用不可の場合、アジャスト機能を使えないようにする
2017-05-31 masterブランチから更新ソースを取り込み
2017-06-01 microSDカード接続のためのコードを差替え
    ・動作確認用の仮モジュールを削除
    ・FatFsのPIC24版コードを取り込み
    （既存ファイルとの混同を避ける為、ファイル名を、fatfs_xxxx と変更）
2017-06-01 ロング・ファイルネーム有効化対応
    fatfs_ffunicode.c をプロジェクトに追加
2017-06-01 リアルタイムクロックがないための仮対応
    後日、リアルタイムクロックモジュールを接続時に、本格対応予定
2017-06-01 fatfsの提供ソースコードを修正
    ・ファイル名の長さ上限を32に変更（プログラムサイズ縮小のため）
    ・ピンアサイン／レジスター名をPIC16F18877に合わせる
    ・再帰呼び出し部分をコメントアウトし、代替えロジックを追加（ACMD送信前にCMD55を送信）
    ・カードスロットの挿入状態チェックをサポートしないよう修正（該当ロジックをコメントアウト）
2017-06-01 テスト用関数を小修正
2017-06-05 回路図を修正
    マイクロＳＤカードスロットＤＩＰ化キットの使用を前提とするよう修正
    http://akizukidenshi.com/catalog/g/gK-05488/
2017-06-12 回路図を修正
    リアルタイムクロックモジュールを増設
    （microSDカードのファイルタイムスタンプを正しく設定するための措置）
2017-06-13 リアルタイムクロックモジュールを組み込み
    ファイルシステム更新等に、RTCCの現在時刻が反映されるよう修正
2017-06-13 時刻アジャスト機能を追加
    UARTから現在時刻を入力し、RTCCに設定する機能を追加
2017-06-14 回路図のコメントがおかしいので修正
2017-06-14 定数修正
    LEDの電流制限抵抗値
2017-06-23 使用部品の見直し
    回路じたいは変えていません。
2017-06-26 使用部品の見直し
    電池ホルダー部品を差し替え
2017-06-27 使用部品の見直し
    microSD変換基板用コネクターのデザインを差し替え
    I2Cインターフェース用品を追加
2017-06-28 回路修正
    ・ANA0はポートごとの接続コネクターに集約するので一旦配線解除
    ・UART/I2C接続コネクターの説明コメントを修正
2017-07-02 GPIO接続用コネクター増設
2017-07-03 部品仮配置
2017-07-04 部品配置を修正
2017-07-06 部品配置を修正
    パスコン
2017-07-07 部品配置を修正
    SDスロット、液晶ディスプレイなどの配置を考慮し、大幅に見直し
2017-07-08 部品配置を修正
    液晶ディスプレイの外形による見直し発生
2017-07-09 部品配置を修正
    LEDの位置をピンのそばに移動
2017-07-10 タクトスイッチの回路を差替
2017-07-10 部品配置を修正
    LCD、RTCC周辺の部品配置を見直し
2017-07-11 配線作業
2017-07-12 実体配線図の初版
2017-07-13 実体配線図の見直し
